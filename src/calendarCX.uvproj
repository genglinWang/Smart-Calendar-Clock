# Keil uVision project calendarCX.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: calendarCX +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c jq8900.c keyscan.c Text2Voice.c 12864.c ds1302.c dht11.c lunar.c bluetooth.c
